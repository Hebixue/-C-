# IAR project demo.ewp, settings and files
configuration Demo (ARM, debug)
  General.OGChipSelectEditMenu: AC78406YGLA AutoChips AC78406YGLA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: User; ..\..\..\IAR_Pack\CMSIS\Device; ..\..\..\IAR_Pack\CMSIS\Device\ac7840x\include; ..\..\..\IAR_Pack\CMSIS\Device\ac7840x\startup; ..\..\..\IAR_Pack\CMSIS\Device\ac7840x\startup\armc; ..\..\..\IAR_Pack\CMSIS\Device\common; ..\..\..\IAR_Pack\CMSIS\Driver\inc; ..\..\..\IAR_Pack\CMSIS\Driver\src\acmp; ..\..\..\IAR_Pack\CMSIS\Driver\src\adc; ..\..\..\IAR_Pack\CMSIS\Driver\src\can; ..\..\..\IAR_Pack\CMSIS\Driver\src\ckgen; ..\..\..\IAR_Pack\CMSIS\Driver\src\cmu; ..\..\..\IAR_Pack\CMSIS\Driver\src\crc; ..\..\..\IAR_Pack\CMSIS\Driver\src\cse; ..\..\..\IAR_Pack\CMSIS\Driver\src\ctu; ..\..\..\IAR_Pack\CMSIS\Driver\src\dma; ..\..\..\IAR_Pack\CMSIS\Driver\src\eim; ..\..\..\IAR_Pack\CMSIS\Driver\src\eio; ..\..\..\IAR_Pack\CMSIS\Driver\src\ewdg; ..\..\..\IAR_Pack\CMSIS\Driver\src\flash; ..\..\..\IAR_Pack\CMSIS\Driver\src\gpio; ..\..\..\IAR_Pack\CMSIS\Driver\src\i2c; ..\..\..\IAR_Pack\CMSIS\Driver\src\lin; ..\..\..\IAR_Pack\CMSIS\Driver\src\mpu; ..\..\..\IAR_Pack\CMSIS\Driver\src\pbr; ..\..\..\IAR_Pack\CMSIS\Driver\src\pct; ..\..\..\IAR_Pack\CMSIS\Driver\src\pdt; ..\..\..\IAR_Pack\CMSIS\Driver\src\pwm; ..\..\..\IAR_Pack\CMSIS\Driver\src\rcm; ..\..\..\IAR_Pack\CMSIS\Driver\src\rtc; ..\..\..\IAR_Pack\CMSIS\Driver\src\smu; ..\..\..\IAR_Pack\CMSIS\Driver\src\spi; ..\..\..\IAR_Pack\CMSIS\Driver\src\spm; ..\..\..\IAR_Pack\CMSIS\Driver\src\sram; ..\..\..\IAR_Pack\CMSIS\Driver\src\timer; ..\..\..\IAR_Pack\CMSIS\Driver\src\uart; ..\..\..\IAR_Pack\CMSIS\Driver\src\wdg; ..\..\..\IAR_Pack\CMSIS\Rtos\osif
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../IAR_Pack/CMSIS/Device/ac7840x/startup/: debugout_ac7840x.c system_ac7840x.c
    ../../../IAR_Pack/CMSIS/Device/ac7840x/startup/iar/: startup_ac7840x.s
  group Driver
    ../../../IAR_Pack/CMSIS/Driver/src/acmp/: acmp_drv.c acmp_hw.c acmp_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/adc/: adc_drv.c adc_hw.c adc_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/can/: can_drv.c can_hw.c can_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/ckgen/: ckgen_drv.c ckgen_hw.c
    ../../../IAR_Pack/CMSIS/Driver/src/cmu/: cmu_drv.c
    ../../../IAR_Pack/CMSIS/Driver/src/crc/: crc_drv.c crc_hw.c
    ../../../IAR_Pack/CMSIS/Driver/src/cse/: cse_drv.c cse_hw.c
    ../../../IAR_Pack/CMSIS/Driver/src/ctu/: ctu_drv.c ctu_hw.c
    ../../../IAR_Pack/CMSIS/Driver/src/dma/: dma_drv.c dma_hw.c dma_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/eim/: eim_drv.c eim_hw.c
    ../../../IAR_Pack/CMSIS/Driver/src/eio/: eio_comm.c eio_i2c_drv.c eio_i2s_drv.c eio_spi_drv.c eio_uart_drv.c
    ../../../IAR_Pack/CMSIS/Driver/src/ewdg/: ewdg_drv.c ewdg_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/flash/: flash_drv.c flash_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/gpio/: gpio_drv.c gpio_irq.c port_hw.c
    ../../../IAR_Pack/CMSIS/Driver/src/i2c/: i2c_drv.c i2c_hw.c i2c_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/lin/: lin_drv.c
    ../../../IAR_Pack/CMSIS/Driver/src/mpu/: mpu_drv.c mpu_hw.c
    ../../../IAR_Pack/CMSIS/Driver/src/pbr/: pbr_drv.c
    ../../../IAR_Pack/CMSIS/Driver/src/pct/: pct_drv.c pct_hw.c pct_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/pdt/: pdt_drv.c pdt_hw.c pdt_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/pwm/: pwm_common.c pwm_hw.c pwm_input.c pwm_irq.c pwm_output.c
    ../../../IAR_Pack/CMSIS/Driver/src/rcm/: rcm_drv.c
    ../../../IAR_Pack/CMSIS/Driver/src/rtc/: rtc_drv.c rtc_hw.c rtc_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/smu/: smu_drv.c smu_hw.c
    ../../../IAR_Pack/CMSIS/Driver/src/spi/: spi_hw.c spi_irq.c spi_master_drv.c spi_shared_function.c spi_slave_drv.c
    ../../../IAR_Pack/CMSIS/Driver/src/spm/: spm_drv.c spm_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/sram/: sram_drv.c sram_hw.c sram_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/timer/: timer_drv.c timer_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/uart/: uart_drv.c uart_hw.c uart_irq.c
    ../../../IAR_Pack/CMSIS/Driver/src/wdg/: wdg_drv.c wdg_hw.c wdg_irq.c
  group Rtos
    ../../../IAR_Pack/CMSIS/Rtos/osif/: osif_baremetal.c
  group User
    User/: clock_config.c gpio.c main.c spi.c
