# Keil uVision project demo.uvprojx, settings and files
target Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AC78406HGLA AutoChips
  pack: AutoChips.AC7840x_DFP.3.6.1
  cpu: IRAM(0x1FFF0000,0x00010000) IRAM2(0x20000000,0x0000F000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0xf000
  group User
    ./User/: clock_config.c gpio.c main.c CAN.c spi.c Fortissimo.c LF.c RF.c timer.c
software components: CMSIS:CORE 5.6.0, Board Support:AC7840x Development Kit:Debug 1.0.0, Device:ATC Drivers:CAN 1.1.0, Device:ATC Drivers:CKGEN 3.1.0, Device:ATC Drivers:DMA 1.2.0, Device:ATC Drivers:GPIO 1.2.0, Device:ATC Drivers:RCM 1.2.0, Device:ATC Drivers:SPI 3.6.2, Device:ATC Drivers:SPM 1.2.1, Device:ATC Drivers:TIMER 1.1.0, Device:ATC Drivers:UART 1.1.1, Device:ATC OSIF:OSIF 1.1.0, Device:Startup 3.0.5
